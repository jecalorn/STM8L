# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_pwr.c stm8l15x_syscfg.c stm8l15x_usart.c stm8l15x_wfe.c
  group User
    ./: main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h
