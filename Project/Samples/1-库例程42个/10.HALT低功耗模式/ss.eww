<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\45.OLED液晶-硬件IIC\Demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\43.UART Printf\Demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
