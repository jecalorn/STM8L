# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152K4 STM8L152K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo3.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: ; 4438\; STM8L15x_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: Demo.hex
  group 443X
    443x/: radio.c radio_comm.c radio_hal.c si446x_api_lib.c
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_spi.c
  group User
    ./: include.h main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h
