<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\36.精确延时\Demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\10.HALT低功耗模式\Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
