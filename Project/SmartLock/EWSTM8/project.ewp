# IAR project project.ewp, settings and files
configuration STM8L15X_MD(STM8L15xx4_6) (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152K4 STM8L152K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x400
  General.GenHeapSize: 0x400
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc; ..\OLED
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8L15X_HD(STM8L15xx8_16xx8) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152M8 STM8L152M8
  General.GenCodeModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L15X_HD
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1528_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc
configuration STM8L15X_LD(STM8L15xx2_3) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C3 STM8L151C3
  General.GenCodeModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L15X_LD
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc
configuration STM8L05X_LD_VL(STM8L05xx3) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: as above
configuration STM8L05X_MD_VL(STM8L05xx6) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L05X_MD_VL
  ICCSTM8.CCIncludePath2: as above
configuration STM8L05X_HD_VL(STM8L05xx8) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: as above
  group STM8L15x_StdPeriph_Driver
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../KEY/: key.c
    ../: main.c queue.c stm8l15x_it.c system.c
    ../OLED/: OLED_I2C.c
